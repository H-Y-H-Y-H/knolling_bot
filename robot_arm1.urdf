Commit message: Add files via upload

File: robot_arm1.urdf (robot description, URDF)
Before this commit: robot wx200, 11 links, 10 joints
Links:
- link robot_arm: geometry collision mesh filename=meshes/base.stl scale=1 1 1; visual mesh filename=meshes/base.stl scale=1 1 1
